# Keil uVision project mbed.uvprojx, settings and files
target mbed (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446ZEHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mbed +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: DEVICE_RTC=1 DEVICE_SLEEP=1 ARM_MATH_CM4 TARGET_NUCLEO_F446ZE TARGET_STM32F4 __ASSERT_MSG TARGET_RELEASE TARGET_STM32F446xE DEVICE_PORTINOUT=1 TARGET_FF_MORPHO DEVICE_I2C_ASYNCH=1 TARGET_FF_ARDUINO TARGET_RTOS_M4_M7 DEVICE_CAN=1 DEVICE_PORTOUT=1 DEVICE_FLASH=1 DEVICE_STDIO_MESSAGES=1 DEVICE_ANALOGOUT=1 TARGET_LIKE_MBED DEVICE_SERIAL_FC=1 DEVICE_SERIAL=1 DEVICE_ANALOGIN=1 TARGET_LIKE_CORTEX_M4 TARGET_CORTEX_M USB_STM_HAL DEVICE_USTICKER=1 DEVICE_I2C=1 __CORTEX_M4 TARGET_CORTEX TARGET_STM TOOLCHAIN_ARM DEVICE_INTERRUPTIN=1 TOOLCHAIN_ARM_STD __CMSIS_RTOS DEVICE_PWMOUT=1 DEVICE_SERIAL_ASYNCH=1 MBED_BUILD_TIMESTAMP=1540952221.67 TARGET_FAMILY_STM32 DEVICE_SPI=1 __MBED__=1 DEVICE_SPISLAVE=1 DEVICE_LPTICKER=1 DEVICE_PORTIN=1 TARGET_M4 __FPU_PRESENT=1 DEVICE_I2CSLAVE=1 USBHOST_OTHER DEVICE_SPI_ASYNCH=1 TRANSACTION_QUEUE_SIZE_SPI=2 __MBED_CMSIS_RTOS_CM TARGET_STM32F446ZE
  c misc: --no_rtti --split_sections -c --cpu=Cortex-M4.fp --gnu --apcs=interwork --no_depend_system_headers --md --preinclude=mbed_config.h
  c include: ..\..\app;..\..\config;..\..\drv;..\..\mbed_os;..\..\mbed_os\cmsis;..\..\mbed_os\cmsis\TARGET_CORTEX_M;..\..\mbed_os\drivers;..\..\mbed_os\events;..\..\mbed_os\events\equeue;..\..\mbed_os\hal;..\..\mbed_os\hal\storage_abstraction;..\..\mbed_os\platform;..\..\mbed_os\rtos;..\..\mbed_os\rtos\TARGET_CORTEX;..\..\mbed_os\rtos\TARGET_CORTEX\rtx4;..\..\mbed_os\rtos\TARGET_CORTEX\rtx5\Include;..\..\mbed_os\rtos\TARGET_CORTEX\rtx5\RTX\Config;..\..\mbed_os\rtos\TARGET_CORTEX\rtx5\RTX\Include;..\..\mbed_os\rtos\TARGET_CORTEX\rtx5\RTX\Source;..\..\mbed_os\rtos\TARGET_CORTEX\TARGET_CORTEX_M;..\..\mbed_os\targets\TARGET_STM;..\..\mbed_os\targets\TARGET_STM\TARGET_STM32F4;..\..\mbed_os\targets\TARGET_STM\TARGET_STM32F4\device;..\..\mbed_os\targets\TARGET_STM\TARGET_STM32F4\TARGET_STM32F446xE;..\..\mbed_os\targets\TARGET_STM\TARGET_STM32F4\TARGET_STM32F446xE\device;..\..\mbed_os\targets\TARGET_STM\TARGET_STM32F4\TARGET_STM32F446xE\TARGET_NUCLEO_F446ZE;..\..\mbed_os\usb\targets\TARGET_STM;..\..\mbed_os\usb\targets\TARGET_STM\TARGET_STM32F4\TARGET_STM32F446xE\TARGET_NUCLEO_F446ZE;..\..\mbed_os\usb\USBAudio;..\..\mbed_os\usb\USBDevice;..\..\mbed_os\usb\USBHID;..\..\mbed_os\usb\USBMIDI;..\..\mbed_os\usb\USBMSD;..\..\mbed_os\usb\USBSerial
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M4,-DUSB_STM_HAL,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-DUSBHOST_OTHER,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --show_full_path
  group app
    ../../app/: main.cpp
  group mbed/cmsis
    ../../mbed_os/cmsis/TARGET_CORTEX_M/: mbed_tz_context.c
  group mbed/drivers
    ../../mbed_os/drivers/: AnalogIn.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CAN.cpp Ethernet.cpp FlashIAP.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp MbedCRC.cpp QSPI.cpp RawSerial.cpp Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp TableCRC.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp UARTSerial.cpp
  group mbed/events
    ../../mbed_os/events/: EventQueue.cpp mbed_shared_queues.cpp
    ../../mbed_os/events/equeue/: equeue_mbed.cpp equeue.c equeue_posix.c
  group mbed/hal
    ../../mbed_os/hal/: mbed_critical_section_api.c mbed_flash_api.c mbed_gpio.c mbed_itm_api.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_sleep_manager.c mbed_ticker_api.c mbed_us_ticker_api.c LowPowerTickerWrapper.cpp mbed_lp_ticker_wrapper.cpp
  group mbed/platform
    ../../mbed_os/platform/: mbed_application.c mbed_assert.c mbed_board.c mbed_critical.c mbed_error.c mbed_error_hist.c mbed_interface.c mbed_mktime.c mbed_sdk_boot.c mbed_semihost_api.c mbed_stats.c mbed_wait_api_no_rtos.c ATCmdParser.cpp CallChain.cpp FileBase.cpp FileHandle.cpp FilePath.cpp FileSystemHandle.cpp LocalFileSystem.cpp mbed_alloc_wrappers.cpp mbed_mem_trace.cpp mbed_poll.cpp mbed_retarget.cpp mbed_rtc_time.cpp mbed_wait_api_rtos.cpp Stream.cpp
  group mbed/rtos
    ../../mbed_os/rtos/TARGET_CORTEX/: mbed_boot.c mbed_rtos_rtx.c mbed_rtx_handlers.c mbed_rtx_idle.cpp SysTimer.cpp
    ../../mbed_os/rtos/TARGET_CORTEX/rtx4/: cmsis_os1.c
    ../../mbed_os/rtos/TARGET_CORTEX/rtx5/Source/: os_systick.c os_tick_ptim.c
    ../../mbed_os/rtos/TARGET_CORTEX/rtx5/RTX/Config/: RTX_Config.c
    ../../mbed_os/rtos/TARGET_CORTEX/rtx5/RTX/Source/: rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    ../../mbed_os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_ARM/TARGET_RTOS_M4_M7/: irq_cm4f.S
    ../../mbed_os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/: mbed_rtx_fault_handler.c
    ../../mbed_os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/TOOLCHAIN_ARM/: except.S
    ../../mbed_os/rtos/TARGET_CORTEX/TOOLCHAIN_ARM_STD/: mbed_boot_arm_std.c
    ../../mbed_os/rtos/: ConditionVariable.cpp EventFlags.cpp Kernel.cpp Mutex.cpp RtosTimer.cpp Semaphore.cpp ThisThread.cpp Thread.cpp
  group mbed/target
    ../../mbed_os/targets/TARGET_STM/: analogin_api.c analogout_api.c can_api.c gpio_api.c gpio_irq_api.c hal_tick_overrides.c i2c_api.c lp_ticker.c mbed_crc_api.c mbed_overrides.c pinmap.c port_api.c pwmout_api.c qspi_api.c rtc_api.c serial_api.c sleep.c stm_spi_api.c trng_api.c us_ticker.c
    ../../mbed_os/targets/TARGET_STM/TARGET_STM32F4/: analogin_device.c analogout_device.c flash_api.c gpio_irq_device.c hal_init_pre.c pwmout_device.c serial_device.c spi_api.c
    ../../mbed_os/targets/TARGET_STM/TARGET_STM32F4/device/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_can_legacy.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c system_stm32f4xx.c
    ../../mbed_os/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/device/TOOLCHAIN_ARM_STD/: startup_stm32f446xx.S
    ../../mbed_os/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/TARGET_NUCLEO_F446ZE/: system_clock.c PeripheralPins.c
  group mbed/USB_target
    ../../mbed_os/usb/targets/TARGET_STM/: USBHAL_STM32.cpp USBHAL_STM32F4.cpp
  group mbed/USB_audio
    ../../mbed_os/usb/USBAudio/: USBAudio.cpp
  group mbed/USB_device
    ../../mbed_os/usb/USBDevice/: USBDevice.cpp
  group mbed/USB_HID
    ../../mbed_os/usb/USBHID/: USBHID.cpp USBKeyboard.cpp USBMouse.cpp USBMouseKeyboard.cpp
  group mbed/USB_MIDI
    ../../mbed_os/usb/USBMIDI/: USBMIDI.cpp
  group mbed/USB_MSD
    ../../mbed_os/usb/USBMSD/: USBMSD.cpp
  group mbed/USB_serial
    ../../mbed_os/usb/USBSerial/: USBCDC.cpp USBSerial.cpp
